# Keil uVision project project-hw04.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project-hw04
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM32F429I_DISCO,
  c include: .\;Libraries\CMSIS\Include;Libraries\CMSIS\Device\ST\STM32F4xx\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;Utilities\STM32F429I-Discovery
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group STM32F429I-Discovery
    ./Utilities/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f429i_discovery_l3gd20.c
  group STM32F4xx_StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma2d.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c
  group Source
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c mems.c adc.c
  group Include
    ./: main.h mems.h stm32f4xx_conf.h stm32f4xx_it.h adc.h
software components: CMSIS:CORE 5.3.0
